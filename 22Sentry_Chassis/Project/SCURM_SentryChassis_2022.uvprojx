# Keil uVision project SCURM_SentryChassis_2022.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SCURM_SentryGimbalT_2022
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_AC_V6,USE_SCU_board_Crystal_oscillator_25MHz,STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\User;..\Driver\Core;..\Driver\Std_lib\inc;..\Driver\Dsp_lib\inc;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\SentryCode\bsp\inc;..\SentryCode\com\inc;..\SentryCode\sys\inc;..\SentryCode\support\inc;..\SentryCode\motor\inc;..\SentryCode\state\inc;..\SentryCode\Task\inc;..\SentryCode\judge\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp stm32f4xx_it.c system_stm32f4xx.c
  group System
    ../SentryCode/sys/src/: cycle.cpp sys.cpp
    ../SentryCode/sys/inc/: cycle.h sys.h gpio.h
  group Chassis_Task
    ../SentryCode/Task/src/: StartTask.cpp ChassisTask.cpp StateTask.cpp task_virtual.cpp debugTask.cpp canComTask.cpp
    ../SentryCode/Task/inc/: StartTask.h ChassisTask.h StateTask.h task_virtual.h MyTask.h debugTask.h
  group Chassis_State
    ../SentryCode/state/src/: stateAction.cpp
    ../SentryCode/state/inc/: stateAction.h
  group Chassis_Motor
    ../SentryCode/motor/src/: control.cpp encoder.cpp
    ../SentryCode/motor/inc/: control.h encoder.h
  group Chassis_Com
    ../SentryCode/com/src/: ch2gm.cpp
    ../SentryCode/com/inc/: ch2gm.h
  group Chassis_BSP
    ../SentryCode/bsp/src/: can.cpp debug_usart.cpp led.cpp rng.cpp timer.cpp optoeSwitch.cpp
    ../SentryCode/bsp/inc/: can.h debug_usart.h led.h rng.h timer.h
  group Chassis_Support
    ../SentryCode/support/src/: pid.cpp motorMsg.cpp
    ../SentryCode/support/inc/: pid.h motorMsg.h
  group Chassis_Judge
    ../SentryCode/judge/src/: CRCCheck.c judge.c
    ../SentryCode/judge/inc/: CRCCheck.h judge.h judgeStruct.h
  group core
    ../Driver/Core/: startup_stm32f40_41xxx.s
  group STDLib
    ../Driver/Std_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSPLib
    ../Driver/Dsp_lib/: arm_cortexM4lf_math.lib
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
